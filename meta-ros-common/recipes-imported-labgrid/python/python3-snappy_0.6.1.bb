# Imported as-is from
# https://github.com/labgrid-project/meta-labgrid/commit/0bdddba7449375b809b9f470318f4538dda27283

inherit setuptools3
require python-snappy.inc

SRC_URI[md5sum] = "fc84cfa3526fba06d66f0d0b2e764300"
SRC_URI[sha256sum] = "b6a107ab06206acc5359d4c5632bd9b22d448702a79b3169b0c62e0fb808bb2a"
